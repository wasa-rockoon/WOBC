# Repository wasa-rockoon/WOBC (continued)

## KiCad design hardware/modules/CMG/CMGSon/CMGSon.kicad_pcb (continued)

Parts:
C901, C907: 100nF; C_0402_1005Metric; LCSC C1525
C902, C903, C908, C909, C910: 22uF; C_0805_2012Metric; LCSC C45783
C904, C905: 10uF; C_0603_1608Metric; LCSC C96446
C906: 100nF; C_0603_1608Metric; LCSC C14663
D901: SMBJ15A; D_SMB; LCSC SMBJ15A
J901: Servo; JST_PH_B4B-PH-K_1x04_P2.00mm_Vertical
L901: 3.3uH; L_Sunlord_SWPA5040S; LCSC C3033018
LED103: Servo; LED_0805_2012Metric; LCSC C2296
R901: 20mΩ; R_2010_5025Metric; LCSC C474229
R902: 150mΩ; R_1206_3216Metric; LCSC C37936
R903: 1k; R_0402_1005Metric; LCSC C25123
R904: 100k; R_0402_1005Metric; LCSC C25741
R905: 68.1k; R_0402_1005Metric; LCSC C11537
R906: 10k; R_0402_1005Metric; LCSC C25744
R907: 470; R_0402_1005Metric; LCSC C25117
U901: TPS565201DDCR; TSOT-23-6
U902: INA226; VSSOP-10_3x3mm_P0.5mm; LCSC C49851

Connections:
/ESP32Core/GPIO9/ADC1_CH8: J901.1; also elsewhere on the board
/ESP32Core/GPIO10/ADC1_CH9: J901.4; also elsewhere on the board
/I2C_SCL: U902.5 (SCL); also elsewhere on the board
/I2C_SDA: U902.4 (SDA); also elsewhere on the board
/MotorControl/LiPo_{out}: C904.1, C905.1, C906.1, D901.1 (K), R902.1, U901.3 (VIN); also elsewhere on the board
/Servo/ServoPower: J901.2, R901.1, U902.8 (Vbus), U902.9 (Vin-)
/ServoEN: LED103.2 (A), R903.1; also elsewhere on the board
GND: C902.2, C903.2, C904.2, C905.2, C906.2, C907.2, C908.2, C909.2, C910.2, D901.2 (A), J901.3, R904.2, R906.1, R907.2, U901.1 (GND), U902.7 (GND); also elsewhere on the board
unnamed: C908.1, C909.1, C910.1, R902.2
unnamed: LED103.1 (K), R907.1
unnamed: R903.2, R904.1, U901.5 (EN)
unnamed: C901.1, L901.1, U901.2 (SW)
unnamed: C901.2, U901.6 (VBST)
unnamed: R905.1, R906.2, U901.4 (VFB)
unnamed: C902.1, C903.1, L901.2, R901.2, R905.2, U902.10 (Vin+)
VDD: C907.1, U902.1 (A1), U902.2 (A0), U902.6 (VS); also elsewhere on the board

Notes on the sheet:
入力過電圧保護
I2C ADDR: 0x45
approx.6V

Parts:
C201: 10uF; C_0603_1608Metric; LCSC C96446
C202, C203, C204: 100nF; C_0402_1005Metric; LCSC C1525
D201, D202, D203: 5V; D_SOD-882; LCSC C7420372
D204: ERROR; LED_0805_2012Metric; LCSC C84256
D205: STAT; LED_0805_2012Metric; LCSC C2297
D206: RESET; LED_0805_2012Metric; LCSC C2296
R201, R202: 5.1k; R_0402_1005Metric; LCSC C25905
R203, R207: 10k; R_0402_1005Metric; LCSC C25744
R204, R205, R206: 470; R_0402_1005Metric; LCSC C25117
SW201: BOOT_sw; TVAF06-A020B-R
SW202: RESET_sw; TVAF06-A020B-R
U201: ESP32-S3-WROOM-1
U202: TPS3820; SOT-23-5; LCSC C7719
U203: SN65HVD230; SOIC-8_3.9x4.9mm_P1.27mm; LCSC C12084
USB201: USB_C_Receptacle_USB2.0; USB_C_TYPEC-301S-ACP16X7; LCSC C720625

Connections:
/CANH: U203.7 (CANH); also elsewhere on the board
/CANL: U203.6 (CANL); also elsewhere on the board
/CS: U201.22 (GPIO14/TOUCH14/ADC2_CH3/FSPIWP/FSPIDQS/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); also elsewhere on the board
/ESP32Core/CAN_RX: U201.36 (U0RXD/GPIO44/CLK_OUT2), U203.4 (R)
/ESP32Core/CAN_TX: U201.37 (U0TXD/GPIO43/CLK_OUT1), U203.1 (D)
/ESP32Core/GPIO1/ADC1_CH0: U201.39 (GPIO1/TOUCH1/ADC1_CH0)
/ESP32Core/GPIO2/ADC1_CH1: U201.38 (GPIO2/TOUCH2/ADC1_CH1)
/ESP32Core/GPIO3/ADC1_CH2: U201.15 (GPIO3/TOUCH3/ADC1_CH2)
/ESP32Core/GPIO4/ADC1_CH3: U201.4 (GPIO4/TOUCH4/ADC1_CH3); also elsewhere on the board
/ESP32Core/GPIO5/ADC1_CH4: U201.5 (GPIO5/TOUCH5/ADC1_CH4); also elsewhere on the board
/ESP32Core/GPIO6/ADC1_CH5: U201.6 (GPIO6/TOUCH6/ADC1_CH5); also elsewhere on the board
/ESP32Core/GPIO7/ADC1_CH6: U201.7 (GPIO7/TOUCH7/ADC1_CH6); also elsewhere on the board
/ESP32Core/GPIO8/ADC1_CH7: U201.12 (GPIO8/TOUCH8/ADC1_CH7/SUBSPICS1); also elsewhere on the board
/ESP32Core/GPIO9/ADC1_CH8: U201.17 (GPIO9/TOUCH9/ADC1_CH8/FSPIHD/SUBSPIHD); also elsewhere on the board
/ESP32Core/GPIO10/ADC1_CH9: U201.18 (GPIO10/TOUCH10/ADC1_CH9/FSPICS0/FSPIIO4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); also elsewhere on the board
/ESP32Core/GPIO18: U201.11 (GPIO18/U1RXD/ADC2_CH7/CLK_OUT3); also elsewhere on the board
/ESP32Core/GPIO21: U201.23 (GPIO21); also elsewhere on the board
/ESP32Core/GPIO38: U201.31 (GPIO38/FSPIWP/SUBSPIWP)
/ESP32Core/GPIO39: U201.32 (MTCK/GPIO39/CLK_OUT3/SUBSPICS1)
/ESP32Core/GPIO48: U201.25 (GPIO48/SPICLK_N/SUBSPICLK_N_DIFF)
/ESP32Core/USB_D+: D202.2 (A2), U201.14 (GPIO20/U1CTS/ADC2_CH9/CLK_OUT1/USB_D+), USB201.A6 (D+), USB201.B6 (D+)
/ESP32Core/USB_D-: D203.2 (A2), U201.13 (GPIO19/U1RTS/ADC2_CH8/CLK_OUT2/USB_D-), USB201.A7 (D-), USB201.B7 (D-)
/ESP32Core/WDI: U201.8 (GPIO15/U0RTS/ADC2_CH4/XTAL_32K_P), U202.4 (WDI)
/Heater: U201.33 (MTDO/GPIO40/CLK_OUT2); also elsewhere on the board
/I2C_SCL: R203.2, U201.9 (GPIO16/U0CTS/ADC2_CH5/XTAL_32K_N); also elsewhere on the board
/I2C_SDA: R207.2, U201.10 (GPIO17/U1TXD/ADC2_CH6); also elsewhere on the board
/MISO: U201.19 (GPIO11/TOUCH11/ADC2_CH0/FSPID/FSPIIO5/S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); also elsewhere on the board
/MOSI: U201.21 (GPIO13/TOUCH13/ADC2_CH2/FSPIQ/FSPIIO7/S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); also elsewhere on the board
/SCK: U201.20 (GPIO12/TOUCH12/ADC2_CH1/FSPICLK/FSPIIO6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); also elsewhere on the board
/ServoEN: U201.24 (GPIO47/SPICLK_P/SUBSPICLK_P_DIFF); also elsewhere on the board
GND: C201.1, C202.2, C203.1, C204.1, D201.1 (A1), D202.1 (A1), D203.1 (A1), D204.1 (K), D205.1 (K), R201.2, R202.2, SW201.2, SW202.2, U201.1 (GND), U201.40 (GND), U201.41 (GND), U202.2 (GND), U203.2 (GND), U203.8 (Rs), USB201.A1 (GND), USB201.A12 (GND), USB201.B1 (GND), USB201.B12 (GND), USB201.S1 (SHIELD); also elsewhere on the board
unnamed: D204.2 (A), R204.2
unnamed: D205.2 (A), R205.2
unnamed: D206.2 (A), R206.2
unnamed: SW201.1, U201.27 (GPIO0/BOOT)
unnamed: R204.1, U201.34 (MTDI/GPIO41/CLK_OUT1)
unnamed: R205.1, U201.35 (MTMS/GPIO42)
unnamed: SW202.1, U202.3 (MR)
unnamed: R201.1, USB201.A5 (CC1)
unnamed: R202.1, USB201.B5 (CC2)
RESET: D206.1 (K), U201.3 (EN), U202.1 (RESET)
VBUS: D201.2 (A2), USB201.A4 (VBUS), USB201.A9 (VBUS), USB201.B4 (VBUS), USB201.B9 (VBUS); also elsewhere on the board
VDD: C201.2, C202.1, C203.2, C204.2, R203.1, R206.1, R207.1, U201.2 (3V3), U202.5 (VDD), U203.3 (VCC); also elsewhere on the board

Notes on the sheet:
ESP32 S3
Watchdog Timer & Reset
CAN Tranceiver
Pins: https://github.com/atomic14/esp32-s3-pinouts
USB Type-C Connector

Parts:
C301, C303, C305, C306, C307, C308, C312: 10uF; C_0603_1608Metric; LCSC C19702
C302, C304, C309, C310, C311: 100n; C_0402_1005Metric; LCSC C1525
F301: Polyfuse; Fuse_1206_3216Metric; LCSC C883133
J301: HeaterLiPo; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal
J302: THR1; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
J303: THR2; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
J304: Heater; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal
J305: THR3; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
LED301: Heater; LED_0805_2012Metric; LCSC C2296
Q301: NMOS; SOT-23-3; LCSC C20917
R301, R304, R308: 120; R_0402_1005Metric; LCSC C25079
R302, R305, R307, R309, R313: 10k; R_0402_1005Metric; LCSC C25744
R303: 20mΩ; R_2010_5025Metric; LCSC C474229
R306: 510; R_0402_1005Metric; LCSC C25123
R310: 470; R_0402_1005Metric; LCSC C25117
R311: 47k; R_0402_1005Metric; LCSC C25792
R312: 1k; R_0402_1005Metric; LCSC C25123
U301: INA226; VSSOP-10_3x3mm_P0.5mm; LCSC C49851
U302: MCP3424x-xSL; SOIC-14_3.9x8.7mm_P1.27mm
U303: MCP1501-20xSN; SOIC-8_3.9x4.9mm_P1.27mm; LCSC C635893

Connections:
/Heater: LED301.2 (A), R306.2; also elsewhere on the board
/Heater/CH1: C305.1, R301.1, U302.1 (CH1+)
/Heater/CH2: C310.1, R312.1, U302.3 (CH2+)
/Heater/CH3: C307.1, R308.1, U302.11 (CH3+)
/Heater/CH4: C306.1, R304.1, U302.13 (CH4+)
/Heater/VPPheater: F301.2, J301.2, R311.1
/Heater/Vref: C311.2, C312.2, J302.1, J303.1, J305.1, U303.7 (OUT), U303.8 (FB)
/I2C_SCL: U301.5 (SCL), U302.8 (SCL); also elsewhere on the board
/I2C_SDA: U301.2 (A0), U301.4 (SDA), U302.7 (SDA); also elsewhere on the board
GND: C301.2, C302.2, C303.2, C304.2, C305.2, C306.2, C307.2, C308.2, C309.2, C310.2, C311.1, C312.1, J301.1, Q301.2 (S), R302.2, R305.2, R307.2, R309.2, R310.2, R313.2, U301.7 (GND), U302.2 (CH1-), U302.4 (CH2-), U302.5 (V_{SS}), U302.9 (A0), U302.12 (CH3-), U302.14 (CH4-), U303.2 (GND), U303.4 (GND), U303.5 (GND), U303.6 (GND); also elsewhere on the board
unnamed: J302.2, R301.2, R302.1
unnamed: J303.2, R304.2, R305.1
unnamed: J304.2 (Pin_1), R303.1, U301.9 (Vin-)
unnamed: J304.1 (Pin_2), Q301.3 (D)
unnamed: J305.2, R308.2, R309.1
unnamed: LED301.1 (K), R310.1
unnamed: Q301.1 (G), R306.1, R307.1
unnamed: R311.2, R312.2, R313.1
unnamed: F301.1, R303.2, U301.8 (Vbus), U301.10 (Vin+)
VDD: C301.1, C302.1, C303.1, C304.1, C308.1, C309.1, U301.1 (A1), U301.6 (VS), U302.6 (V_{DD}), U302.10 (A1), U303.1 (VDD), U303.3 (~SHDN); also elsewhere on the board

Notes on the sheet:
I2C ADDR : 0x46
Heater
MAX : 1.5A
Temperature
I2C ADDR : 0x6A
---> 2.048V
2S 7.4V

Parts:
C801, C804: 10μF; C_0603_1608Metric; LCSC C96446
C802, C803: 100nF; C_0402_1005Metric; LCSC C1525
U801: BME280; LCSC C92489

Connections:
/I2C_SCL: U801.4 (SCK); also elsewhere on the board
/I2C_SDA: U801.3 (SDI); also elsewhere on the board
GND: C801.2, C802.2, C803.2, C804.2, U801.1 (GND), U801.5 (SDO), U801.7 (GND); also elsewhere on the board
VDD: C801.1, C802.1, C803.1, C804.1, U801.2 (CSB), U801.6 (VDDIO), U801.8 (VDD); also elsewhere on the board

Schematic: Logger.kicad_sch

Parts:
C501: 10uF; C_0603_1608Metric; LCSC C96446
MICRO_SD501: TF-01A; LCSC C5155563

Connections:
/CS: MICRO_SD501.2 (CD/DAT3); also elsewhere on the board
/ESP32Core/GPIO21: MICRO_SD501.CD1 (CD); also elsewhere on the board
/MISO: MICRO_SD501.3 (CMD); also elsewhere on the board
/MOSI: MICRO_SD501.7 (DAT0); also elsewhere on the board
/SCK: MICRO_SD501.5 (CLK); also elsewhere on the board
GND: C501.2, MICRO_SD501.6 (VSS), MICRO_SD501.MP1 (SHIELD), MICRO_SD501.MP2 (SHIELD), MICRO_SD501.MP3 (SHIELD), MICRO_SD501.MP4 (SHIELD); also elsewhere on the board
VDD: C501.1, MICRO_SD501.4 (VDD); also elsewhere on the board

Notes on the sheet:
Micro SD Card Slot

Board: 2 copper layers, 60.0 x 60.0 mm, 125 parts (3 on the bottom side), 70 nets.

## KiCad design hardware/modules/GS/GS.kicad_pcb

Board: 2 copper layers, 60.0 x 60.0 mm, 89 parts (2 on the bottom side), 70 nets.

Parts:
AE101: Antenna; GNSS_Antenna_1212
B101: Board_1U_60x60
BT101: Battery; cr1220
C101, C104, C109, C110, C111, C114, C115, C118, C122: 10uF; C_0603_1608Metric
C102, C103, C105, C106, C107, C108, C116, C117, C123: 100nF; C_0402_1005Metric
C112, C113, C119, C120, C121: 10uF; C_0805_2012Metric
D101, D102, D103: 5V; D_SOD-882
D104: RESET; LED_0805_2012Metric
D105: ERROR; LED_0805_2012Metric
D106: STAT; LED_0805_2012Metric
F101, F102, F103: Polyfuse; Fuse_1206_3216Metric
J101, J103: Jumper; PinHeader_1x02_P1.27mm_Vertical
J102, J104: Conn_01x04_MountingPin; Grove_4P_L_SMD
J105: Battery; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal
J106: LiPo; JST_PH_S2B-PH-K_1x02_P2.00mm_Horizontal
L101: L; L_Wuerth_WE-TPC-3816
LED101: USB Power; LED_0805_2012Metric
LED102: Backup; LED_0805_2012Metric
LED103: CHARGE; LED_0805_2012Metric
LED104: VDD; LED_0805_2012Metric
MICRO_SD101: TF-01A
R101, R102: 5.1k; R_0402_1005Metric
R103, R104, R106: 470; R_0402_1005Metric
R105, R107, R115, R120: 10k; R_0402_1005Metric
R108, R109: 33; R_0402_1005Metric
R110, R111: 120; R_0402_1005Metric
R112, R113, R119, R121, R127: 1k; R_0402_1005Metric
R114, R117, R118, R122, R124: 100k; R_0402_1005Metric
R116, R126: 47k; R_0402_1005Metric
R123: 50mΩ; R_0805_2012Metric
R125: 15k; R_0402_1005Metric
RV101: 10k; Potentiometer_Bourns_TC33X_Vertical
SW101, SW102: RESET_sw; TVAF06-A020B-R
SW103: Power Switch; SW_Slide_SPDT_Angled_CK_OS102011MA1Q
U101: TPS3820; SOT-23-5
U102: SN65HVD230; SOIC-8_3.9x4.9mm_P1.27mm
U103: ESP32-S3-WROOM-1
U104: NEO-M9N-00B; ATGM332D-5N31
U105: MCP73871-1CC; QFN-20-1EP_4x4mm_P0.5mm_EP2.5x2.5mm
U106: TPS2116DRL; SOT-583-8
U107: TPS63070RNMR; VREG_TPS63070RNMR
U108: INA226; VSSOP-10_3x3mm_P0.5mm
U109: PCF8563T; SOIC-8_3.9x4.9mm_P1.27mm
USB101: USB_C_Receptacle_USB2.0; USB_C_TYPEC-301S-ACP16X7
Y101: Crystal; Crystal_SMD_3215-2Pin_3.2x1.5mm

Connections:
+BATT: C123.2, U109.8 (VDD)
/CLK: MICRO_SD101.5 (CLK), U103.20 (GPIO12/TOUCH12/ADC2_CH1/FSPICLK/FSPIIO6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)
/DET: MICRO_SD101.CD1 (CD), U103.17 (GPIO9/TOUCH9/ADC1_CH8/FSPIHD/SUBSPIHD)
/ESP32/CANH: J102.1, J104.1, R110.2, R111.2, U102.7 (CANH)
/ESP32/CANL: J101.2, J102.2, J103.2, J104.2, U102.6 (CANL)
/ESP32/CAN_RX: U102.4 (R), U103.36 (U0RXD/GPIO44/CLK_OUT2)
/ESP32/CAN_TX: U102.1 (D), U103.37 (U0TXD/GPIO43/CLK_OUT1)
/ESP32/GPIO1/ADC1_CH0: R108.1, U103.39 (GPIO1/TOUCH1/ADC1_CH0)
/ESP32/GPIO2/ADC1_CH1: R109.1, U103.38 (GPIO2/TOUCH2/ADC1_CH1)
/ESP32/GPIO18: R119.2, U103.11 (GPIO18/U1RXD/ADC2_CH7/CLK_OUT3), U106.8 (ST)
/ESP32/GPIO38: U103.31 (GPIO38/FSPIWP/SUBSPIWP), U104.8 (RESET_N)
/ESP32/GPIO39: U103.32 (MTCK/GPIO39/CLK_OUT3/SUBSPICS1), U104.3 (TIMEPULSE)
/ESP32/GPIO40: R121.2, U103.33 (MTDO/GPIO40/CLK_OUT2)
/ESP32/USB_D+: D102.2 (A2), U103.14 (GPIO20/U1CTS/ADC2_CH9/CLK_OUT1/USB_D+), USB101.A6 (D+), USB101.B6 (D+)
/ESP32/USB_D-: D103.2 (A2), U103.13 (GPIO19/U1RTS/ADC2_CH8/CLK_OUT2/USB_D-), USB101.A7 (D-), USB101.B7 (D-)
/ESP32/VUSB: D101.2 (A2), F101.1, USB101.A4 (VBUS), USB101.A9 (VBUS), USB101.B4 (VBUS), USB101.B9 (VBUS)
/ESP32/WDI: U101.4 (WDI), U103.8 (GPIO15/U0RTS/ADC2_CH4/XTAL_32K_P)
/GPS/+BATT: BT101.1 (+), C101.2, U104.22 (V_BCKP)
/MISO: MICRO_SD101.7 (DAT0), U103.21 (GPIO13/TOUCH13/ADC2_CH2/FSPIQ/FSPIIO7/S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)
/MOSI: MICRO_SD101.3 (CMD), U103.19 (GPIO11/TOUCH11/ADC2_CH0/FSPID/FSPIIO5/S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)
/PG: U103.23 (GPIO21), U105.6 (~PG)
/SCL: R105.2, U103.9 (GPIO16/U0CTS/ADC2_CH5/XTAL_32K_N), U108.1 (A1), U108.2 (A0), U108.5 (SCL), U109.6 (SCL)
/SDA: R107.2, U103.10 (GPIO17/U1TXD/ADC2_CH6), U108.4 (SDA), U109.5 (SDA)
/SS: MICRO_SD101.2 (CD/DAT3), U103.18 (GPIO10/TOUCH10/ADC1_CH9/FSPICS0/FSPIIO4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)
/STAT1: U103.25 (GPIO48/SPICLK_N/SUBSPICLK_N_DIFF), U105.8 (STAT1/~LBO)
/STAT2: U103.24 (GPIO47/SPICLK_P/SUBSPICLK_P_DIFF), U105.7 (STAT2)
GND: B101.GND, BT101.2 (-), C101.1, C102.1, C103.1, C104.1, C105.2, C106.1, C107.1, C108.1, C109.2, C110.2, C111.2, C112.2, C113.2, C114.2, C115.2, C116.2, C117.2, C118.2, C119.2, C120.2, C121.2, C122.2, C123.1, D101.1 (A1), D102.1 (A1), D103.1 (A1), D105.1 (K), D106.1 (K), J102.4, J102.MP (MountPin), J104.4, J104.MP (MountPin), J105.2, J106.2, LED103.1 (K), MICRO_SD101.6 (VSS), MICRO_SD101.MP1 (SHIELD), MICRO_SD101.MP2 (SHIELD), MICRO_SD101.MP3 (SHIELD), MICRO_SD101.MP4 (SHIELD), R101.2, R102.2, R112.2, R113.2, R114.2, R115.1, R116.1, R122.2, R125.1, R127.2, SW101.2, SW102.2, U101.2 (GND), U102.2 (GND), U102.8 (Rs), U103.1 (GND), U103.40 (GND), U103.41 (GND), U104.10 (GND), U104.12 (GND), U104.13 (GND), U104.24 (GND), U105.9 (~TE), U105.10 (V_{SS}), U105.11 (V_{SS}), U105.21 (V_{SS}), U106.1 (GND), U107.4 (GND), U107.10 (PGND), U107.15 (VSEL), U108.7 (GND), U109.4 (VSS), USB101.A1 (GND), USB101.A12 (GND), USB101.B1 (GND), USB101.B12 (GND), USB101.S1 (SHIELD)
GPSANT1: AE101.1 (A), U104.11 (RF_IN)
unnamed: D104.2 (A), R103.2
unnamed: D105.2 (A), R104.2
unnamed: D106.2 (A), R106.2
unnamed: J101.1, R110.1
unnamed: J103.1, R111.1
unnamed: F102.1, J105.1
unnamed: F103.2, J106.1
unnamed: C109.1, F101.2, LED101.2 (A), R117.1, U105.2 (VPCC), U105.3 (SEL), U105.18 (IN), U105.19 (IN)
unnamed: LED101.1 (K), R112.1
unnamed: C112.1, C113.1, C115.1, C116.1, LED102.2 (A), R120.1, U106.2 (VOUT), U106.7 (VOUT), U107.12_13 (VIN), U108.6 (VS)
unnamed: LED102.1 (K), R119.1
unnamed: LED103.2 (A), R121.1
unnamed: LED104.1 (K), R127.1
unnamed: R113.1, RV101.3
unnamed: R120.2, SW103.2 (B)
unnamed: R122.1, SW103.3 (C), U107.1 (PS/SYNC), U107.14 (EN)
unnamed: SW101.1, U101.3 (MR)
unnamed: SW102.1, U103.27 (GPIO0/BOOT)
unnamed: R104.1, U103.34 (MTDI/GPIO41/CLK_OUT1)
unnamed: R106.1, U103.35 (MTMS/GPIO42)
unnamed: R108.2, U104.21 (RXD_/_SPI_MOSI)
unnamed: R109.2, U104.20 (TXD_/_SPI_MISO)
unnamed: R117.2, U105.17 (CE), U108.3 (~Alert)
unnamed: RV101.2, U105.13 (PROG1)
unnamed: R114.1, U105.12 (PROG3)
unnamed: R115.2, U105.5 (THERM)
unnamed: C114.1, R123.1, U105.14 (V_{BAT}), U105.15 (V_{BAT}), U105.16 (V_{BAT_SENSE}), U108.9 (Vin-)
unnamed: C111.1, R118.1, U105.1 (OUT), U105.20 (OUT), U106.3 (VIN1), U106.5 (MODE)
unnamed: R116.2, R118.2, U106.4 (PR1)
unnamed: C110.1, F102.2, U106.6 (VIN2)
unnamed: R125.2, R126.1, U107.5 (FB)
unnamed: L101.1, U107.11 (L1)
unnamed: L101.2, U107.9 (L2)
unnamed: R124.2, U107.2 (PG)
unnamed: C117.1, U107.3 (VAUX)
unnamed: F103.1, R123.2, U108.8 (Vbus), U108.10 (Vin+)
unnamed: U109.1 (OSCI), Y101.1
unnamed: U109.2 (OSCO), Y101.2
unnamed: R101.1, USB101.A5 (CC1)
unnamed: R102.1, USB101.B5 (CC2)
RESET: D104.1 (K), U101.1 (RESET), U103.3 (EN)
VDD: C102.2, C103.2, C104.2, C105.1, C106.2, C107.2, C108.2, C118.1, C119.1, C120.1, C121.1, C122.1, J102.3, J104.3, LED104.2 (A), MICRO_SD101.4 (VDD), R103.1, R105.1, R107.1, R124.1, R126.2, U101.5 (VDD), U102.3 (VCC), U103.2 (3V3), U104.7 (V_USB), U104.23 (VCC), U107.7_8 (VOUT)
