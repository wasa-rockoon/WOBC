# Repository wasa-rockoon/WOBC (continued)

## KiCad design hardware/modules/Sensing2/Sensing/Sensing.kicad_pcb

Board: 2 copper layers, 80.0 x 60.0 mm, 80 parts (0 on the bottom side), 61 nets.

Parts:
B101: Board_1U_60x60
C201, C202, C204, C308, C309, C402: 100nF; C_0402_1005Metric
C203, C301, C302, C303, C306, C307, C310: 10uF; C_0603_1608Metric
C304, C305, C311, C312, C313: 10uF; C_0805_2012Metric
C401: 10uF; C_0402_1005Metric
D201, D202, D203: 5V; D_SOD-882
D204: RESET; LED_0805_2012Metric
D205: ERROR; LED_0805_2012Metric
D206: STAT; LED_0805_2012Metric
F301, F302, F303: Polyfuse; Fuse_1206_3216Metric
J101: MH-Z19C; JST_PH_B4B-PH-K_1x04_P2.00mm_Vertical
J102: SHT31; JST_PH_B4B-PH-K_1x04_P2.00mm_Vertical
J103: GUVC-T21GH; JST_PH_B3B-PH-K_1x03_P2.00mm_Vertical
J104: MS5611 (MS5607); JST_PH_B4B-PH-K_1x04_P2.00mm_Vertical
J105: LTR390; JST_PH_B4B-PH-K_1x04_P2.00mm_Vertical
J106: 968-046; JST_PH_B4B-PH-K_1x04_P2.00mm_Vertical
J301: Battery; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal
J302: Ext Switch; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal
J303: LiPo; JST_PH_S2B-PH-K_1x02_P2.00mm_Horizontal
L301: L; L_Wuerth_WE-TPC-3816
LED301: USB Power; LED_0805_2012Metric
LED302: Backup; LED_0805_2012Metric
LED303: CHARGE; LED_0805_2012Metric
LED304: VDD; LED_0805_2012Metric
MICRO_SD401: TF-01A
R201, R202: 5.1k; R_0402_1005Metric
R203, R204, R206: 470; R_0402_1005Metric
R205, R207, R304, R309: 10k; R_0402_1005Metric
R301, R302, R308, R310, R316: 1k; R_0402_1005Metric
R303, R306, R307, R311, R313: 100k; R_0402_1005Metric
R305, R315: 47k; R_0402_1005Metric
R312: 50mΩ; R_0805_2012Metric
R314: 15k; R_0402_1005Metric
RV301: 10k; Potentiometer_Bourns_TC33X_Vertical
SW201: RESET_sw; TVAF06-A020B-R
SW301: Power Switch; SW_Slide_SPDT_Angled_CK_OS102011MA1Q
U201: TPS3820; SOT-23-5
U202: SN65HVD230; SOIC-8_3.9x4.9mm_P1.27mm
U203: ESP32-S3-WROOM-1
U301: MCP73871-1CC; QFN-20-1EP_4x4mm_P0.5mm_EP2.5x2.5mm
U302: TPS2116DRL; SOT-583-8
U303: TPS63070RNMR; VREG_TPS63070RNMR
U304: INA226; VSSOP-10_3x3mm_P0.5mm
U401: PCF8563T; SOIC-8_3.9x4.9mm_P1.27mm
USB201: USB_C_Receptacle_USB2.0; USB_C_TYPEC-301S-ACP16X7
Y401: Crystal; Crystal_SMD_3215-2Pin_3.2x1.5mm

Connections:
+BATT: C402.2, U401.8 (VDD)
/ESP32S3/CAN_RX: U202.4 (R), U203.36 (U0RXD/GPIO44/CLK_OUT2)
/ESP32S3/CAN_TX: U202.1 (D), U203.37 (U0TXD/GPIO43/CLK_OUT1)
/ESP32S3/GPIO1/ADC1_CH0: J106.1, U203.39 (GPIO1/TOUCH1/ADC1_CH0)
/ESP32S3/GPIO2/ADC1_CH1: J106.2, U203.38 (GPIO2/TOUCH2/ADC1_CH1)
/ESP32S3/GPIO3/ADC1_CH2: J103.2, U203.15 (GPIO3/TOUCH3/ADC1_CH2)
/ESP32S3/GPIO4/ADC1_CH3: U203.4 (GPIO4/TOUCH4/ADC1_CH3), U301.7 (STAT2)
/ESP32S3/GPIO5/ADC1_CH4: U203.5 (GPIO5/TOUCH5/ADC1_CH4), U301.8 (STAT1/~LBO)
/ESP32S3/GPIO6/ADC1_CH5: R308.2, U203.6 (GPIO6/TOUCH6/ADC1_CH5), U302.8 (ST)
/ESP32S3/GPIO7/ADC1_CH6: U203.7 (GPIO7/TOUCH7/ADC1_CH6), U301.6 (~PG)
/ESP32S3/GPIO9/ADC1_CH8: MICRO_SD401.5 (CLK), U203.17 (GPIO9/TOUCH9/ADC1_CH8/FSPIHD/SUBSPIHD)
/ESP32S3/GPIO10/ADC1_CH9: MICRO_SD401.7 (DAT0), U203.18 (GPIO10/TOUCH10/ADC1_CH9/FSPICS0/FSPIIO4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)
/ESP32S3/GPIO11: MICRO_SD401.3 (CMD), U203.19 (GPIO11/TOUCH11/ADC2_CH0/FSPID/FSPIIO5/S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)
/ESP32S3/GPIO12: MICRO_SD401.2 (CD/DAT3), U203.20 (GPIO12/TOUCH12/ADC2_CH1/FSPICLK/FSPIIO6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)
/ESP32S3/GPIO18: R310.2, U203.11 (GPIO18/U1RXD/ADC2_CH7/CLK_OUT3)
/ESP32S3/USB_D+: D202.2 (A2), U203.14 (GPIO20/U1CTS/ADC2_CH9/CLK_OUT1/USB_D+), USB201.A6 (D+), USB201.B6 (D+)
/ESP32S3/USB_D-: D203.2 (A2), U203.13 (GPIO19/U1RTS/ADC2_CH8/CLK_OUT2/USB_D-), USB201.A7 (D-), USB201.B7 (D-)
/ESP32S3/VUSB: D201.2 (A2), F301.1, USB201.A4 (VBUS), USB201.A9 (VBUS), USB201.B4 (VBUS), USB201.B9 (VBUS)
/ESP32S3/WDI: U201.4 (WDI), U203.8 (GPIO15/U0RTS/ADC2_CH4/XTAL_32K_P)
/RX: J101.2, U203.21 (GPIO13/TOUCH13/ADC2_CH2/FSPIQ/FSPIIO7/S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)
/SCL: J102.3, J104.3, J105.3, R205.2, U203.9 (GPIO16/U0CTS/ADC2_CH5/XTAL_32K_N), U304.1 (A1), U304.2 (A0), U304.5 (SCL), U401.6 (SCL)
/SDA: J102.2, J104.4, J105.4, R207.2, U203.10 (GPIO17/U1TXD/ADC2_CH6), U304.4 (SDA), U401.5 (SDA)
/TX: J101.1, U203.22 (GPIO14/TOUCH14/ADC2_CH3/FSPIWP/FSPIDQS/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)
GND: B101.GND, C201.1, C202.1, C203.1, C204.2, C301.2, C302.2, C303.2, C304.2, C305.2, C306.2, C307.2, C308.2, C309.2, C310.2, C311.2, C312.2, C313.2, C401.2, C402.1, D201.1 (A1), D202.1 (A1), D203.1 (A1), D205.1 (K), D206.1 (K), J101.3, J102.4, J103.3, J104.2, J105.2, J106.3, J301.2, J303.2, LED303.1 (K), MICRO_SD401.6 (VSS), MICRO_SD401.MP1 (SHIELD), MICRO_SD401.MP2 (SHIELD), MICRO_SD401.MP3 (SHIELD), MICRO_SD401.MP4 (SHIELD), R201.2, R202.2, R301.2, R302.2, R303.2, R304.1, R305.1, R311.2, R314.1, R316.2, SW201.2, U201.2 (GND), U202.2 (GND), U202.8 (Rs), U203.1 (GND), U203.40 (GND), U203.41 (GND), U301.9 (~TE), U301.10 (V_{SS}), U301.11 (V_{SS}), U301.21 (V_{SS}), U302.1 (GND), U303.4 (GND), U303.10 (PGND), U303.15 (VSEL), U304.7 (GND), U401.4 (VSS), USB201.A1 (GND), USB201.A12 (GND), USB201.B1 (GND), USB201.B12 (GND), USB201.S1 (SHIELD)
unnamed: D204.2 (A), R203.2
unnamed: D205.2 (A), R204.2
unnamed: D206.2 (A), R206.2
unnamed: F302.1, J301.1
unnamed: J302.1, R309.2, SW301.2 (B)
unnamed: J302.2, R311.1, SW301.3 (C), U303.1 (PS/SYNC), U303.14 (EN)
unnamed: F303.2, J303.1
unnamed: C301.1, F301.2, LED301.2 (A), R306.1, U301.2 (VPCC), U301.3 (SEL), U301.18 (IN), U301.19 (IN)
unnamed: LED301.1 (K), R301.1
unnamed: C304.1, C305.1, C307.1, C308.1, LED302.2 (A), R309.1, U302.2 (VOUT), U302.7 (VOUT), U303.12_13 (VIN), U304.6 (VS)
unnamed: LED302.1 (K), R308.1
unnamed: LED303.2 (A), R310.1
unnamed: LED304.1 (K), R316.1
unnamed: R302.1, RV301.3
unnamed: SW201.1, U201.3 (MR)
unnamed: R204.1, U203.34 (MTDI/GPIO41/CLK_OUT1)
unnamed: R206.1, U203.35 (MTMS/GPIO42)
unnamed: R306.2, U301.17 (CE), U304.3 (~Alert)
unnamed: RV301.2, U301.13 (PROG1)
unnamed: R303.1, U301.12 (PROG3)
unnamed: R304.2, U301.5 (THERM)
unnamed: C306.1, R312.1, U301.14 (V_{BAT}), U301.15 (V_{BAT}), U301.16 (V_{BAT_SENSE}), U304.9 (Vin-)
unnamed: C303.1, R307.1, U301.1 (OUT), U301.20 (OUT), U302.3 (VIN1), U302.5 (MODE)
unnamed: R305.2, R307.2, U302.4 (PR1)
unnamed: C302.1, F302.2, U302.6 (VIN2)
unnamed: R314.2, R315.1, U303.5 (FB)
unnamed: L301.1, U303.11 (L1)
unnamed: L301.2, U303.9 (L2)
unnamed: R313.2, U303.2 (PG)
unnamed: C309.1, U303.3 (VAUX)
unnamed: F303.1, R312.2, U304.8 (Vbus), U304.10 (Vin+)
unnamed: U401.1 (OSCI), Y401.1
unnamed: U401.2 (OSCO), Y401.2
unnamed: R201.1, USB201.A5 (CC1)
unnamed: R202.1, USB201.B5 (CC2)
RESET: D204.1 (K), U201.1 (RESET), U203.3 (EN)
VDD: C201.2, C202.2, C203.2, C204.1, C310.1, C311.1, C312.1, C313.1, C401.1, J101.4, J102.1, J103.1, J104.1, J105.1, J106.4, LED304.2 (A), MICRO_SD401.4 (VDD), R203.1, R205.1, R207.1, R313.1, R315.2, U201.5 (VDD), U202.3 (VCC), U203.2 (3V3), U303.7_8 (VOUT)

## KiCad design hardware/modules/Separation/Separation.kicad_pcb

Parts:
B101: Board_1U_60x60
BT101: Battery; cr1220
C101: 10uF; C_0603_1608Metric; LCSC C19702

Connections:
GND: B101.GND, BT101.2 (-), C101.1; also elsewhere on the board
GPS_Backup: BT101.1 (+), C101.2; also elsewhere on the board

Parts:
C201: 10uF; C_0603_1608Metric; LCSC C96446
C202, C203, C204: 100nF; C_0402_1005Metric; LCSC C1525
D201, D202, D203: 5V; D_SOD-882; LCSC C7420372
D204: ERROR; LED_0805_2012Metric; LCSC C84256
D205: STAT; LED_0805_2012Metric; LCSC C2297
D206: RESET; LED_0805_2012Metric; LCSC C2296
R201, R202: 5.1k; R_0402_1005Metric; LCSC C25905
R203, R207: 10k; R_0402_1005Metric; LCSC C25744
R204, R205, R206: 470; R_0402_1005Metric; LCSC C25117
SW201: Boot_sw; TVAF06-A020B-R
SW202: RESET_sw; TVAF06-A020B-R
U201: ESP32-S3-WROOM-1
U202: TPS3820; SOT_23_5; LCSC C7719
U203: SN65HVD230; SOIC-8_3.9x4.9mm_P1.27mm; LCSC C12084
USB201: USB_C_Receptacle_USB2.0; USB_C_TYPEC-301S-ACP16X7; LCSC C720625

Connections:
/CANH: U203.7 (CANH); also elsewhere on the board
/CANL: U203.6 (CANL); also elsewhere on the board
/CS: U201.17 (GPIO9/TOUCH9/ADC1_CH8/FSPIHD/SUBSPIHD); also elsewhere on the board
/DET: U201.18 (GPIO10/TOUCH10/ADC1_CH9/FSPICS0/FSPIIO4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); also elsewhere on the board
/ESP32core/CAN_RX: U201.36 (U0RXD/GPIO44/CLK_OUT2), U203.4 (R)
/ESP32core/CAN_TX: U201.37 (U0TXD/GPIO43/CLK_OUT1), U203.1 (D)
/ESP32core/GPIO1/ADC1_CH0: U201.39 (GPIO1/TOUCH1/ADC1_CH0)
/ESP32core/GPIO2/ADC1_CH1: U201.38 (GPIO2/TOUCH2/ADC1_CH1); also elsewhere on the board
/ESP32core/GPIO3/ADC1_CH2: U201.15 (GPIO3/TOUCH3/ADC1_CH2)
/ESP32core/GPIO4/ADC1_CH3: U201.4 (GPIO4/TOUCH4/ADC1_CH3); also elsewhere on the board
/ESP32core/GPIO5/ADC1_CH4: U201.5 (GPIO5/TOUCH5/ADC1_CH4); also elsewhere on the board
/ESP32core/GPIO6/ADC1_CH5: U201.6 (GPIO6/TOUCH6/ADC1_CH5); also elsewhere on the board
/ESP32core/GPIO7/ADC1_CH6: U201.7 (GPIO7/TOUCH7/ADC1_CH6)
/ESP32core/GPIO14: U201.22 (GPIO14/TOUCH14/ADC2_CH3/FSPIWP/FSPIDQS/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); also elsewhere on the board
/ESP32core/GPIO18: U201.11 (GPIO18/U1RXD/ADC2_CH7/CLK_OUT3)
/ESP32core/GPIO21: U201.23 (GPIO21); also elsewhere on the board
/ESP32core/GPIO40: U201.33 (MTDO/GPIO40/CLK_OUT2); also elsewhere on the board
/ESP32core/USB_D+: D202.2 (A2), U201.14 (GPIO20/U1CTS/ADC2_CH9/CLK_OUT1/USB_D+), USB201.A6 (D+), USB201.B6 (D+)
/ESP32core/USB_D-: D203.2 (A2), U201.13 (GPIO19/U1RTS/ADC2_CH8/CLK_OUT2/USB_D-), USB201.A7 (D-), USB201.B7 (D-)
/ESP32core/WDI: U201.8 (GPIO15/U0RTS/ADC2_CH4/XTAL_32K_P), U202.4 (WDI)
/GPS_RTX: U201.31 (GPIO38/FSPIWP/SUBSPIWP); also elsewhere on the board
/GPS_TRX: U201.32 (MTCK/GPIO39/CLK_OUT3/SUBSPICS1); also elsewhere on the board
/Ldet: U201.12 (GPIO8/TOUCH8/ADC1_CH7/SUBSPICS1); also elsewhere on the board
/MISO: U201.19 (GPIO11/TOUCH11/ADC2_CH0/FSPID/FSPIIO5/S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); also elsewhere on the board
/MOSI: U201.21 (GPIO13/TOUCH13/ADC2_CH2/FSPIQ/FSPIIO7/S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); also elsewhere on the board
/SCK: U201.20 (GPIO12/TOUCH12/ADC2_CH1/FSPICLK/FSPIIO6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); also elsewhere on the board
/SCL: R203.2, U201.9 (GPIO16/U0CTS/ADC2_CH5/XTAL_32K_N); also elsewhere on the board
/SDA: R207.2, U201.10 (GPIO17/U1TXD/ADC2_CH6); also elsewhere on the board
/Separate/IGNITE+: U201.25 (GPIO48/SPICLK_N/SUBSPICLK_N_DIFF); also elsewhere on the board
/Separate/IGNITE-: U201.24 (GPIO47/SPICLK_P/SUBSPICLK_P_DIFF); also elsewhere on the board
GND: C201.1, C202.2, C203.1, C204.1, D201.1 (A1), D202.1 (A1), D203.1 (A1), D204.1 (K), D205.1 (K), R201.2, R202.2, SW201.2, SW202.2, U201.1 (GND), U201.40 (GND), U201.41 (GND), U202.2 (GND), U203.2 (GND), U203.8 (Rs), USB201.A1 (GND), USB201.A12 (GND), USB201.B1 (GND), USB201.B12 (GND), USB201.S1 (SHIELD); also elsewhere on the board
unnamed: D204.2 (A), R204.2
unnamed: D205.2 (A), R205.2
unnamed: D206.2 (A), R206.2
unnamed: SW201.1, U201.27 (GPIO0/BOOT)
unnamed: R204.1, U201.34 (MTDI/GPIO41/CLK_OUT1)
unnamed: R205.1, U201.35 (MTMS/GPIO42)
unnamed: SW202.1, U202.3 (MR)
unnamed: R201.1, USB201.A5 (CC1)
unnamed: R202.1, USB201.B5 (CC2)
RESET: D206.1 (K), U201.3 (EN), U202.1 (RESET)
VBUS: D201.2 (A2), USB201.A4 (VBUS), USB201.A9 (VBUS), USB201.B4 (VBUS), USB201.B9 (VBUS); also elsewhere on the board
VDD: C201.2, C202.1, C203.2, C204.2, R203.1, R206.1, R207.1, U201.2 (3V3), U202.5 (VDD), U203.3 (VCC); also elsewhere on the board

Notes on the sheet:
ESP32 S3
Watchdog Timer & Reset
CAN Tranceiver
Pins: https://github.com/atomic14/esp32-s3-pinouts
USB Type-C Connector
CC pin 56kΩ for 0.5A 22kΩ for 1.5A 10kΩ for 3.0A

Parts:
C701, C702: 100nF; C_0402_1005Metric; LCSC C1525
C703: 100nF; C_0402_1005Metric
D701, D702, D703: 5V; D_SOD-882D; LCSC C7420372
J701: SMA; SMA_Amphenol_132203-12_Horizontal; LCSC C2693813
L701: 27nH, 300mA; L_0402_1005Metric
R701: 10; R_0402_1005Metric; LCSC C25077
R702, R703: 5.1k; R_0402_1005Metric; LCSC C25905
R704, R705: 33; R_0402_1005Metric; LCSC C25105
U701: NEO-M9N-00B; ATGM332D-5N31
USB701: USB_C_Receptacle_USB2.0; USB_C_TYPEC-301S-ACP16X7; LCSC C720625

Connections:
/ESP32core/GPIO21: U701.3 (TIMEPULSE); also elsewhere on the board
/ESP32core/GPIO40: U701.8 (RESET_N); also elsewhere on the board
/GPS/USB_D+: D702.2 (A2), U701.6 (USB_DP), USB701.A6 (D+), USB701.B6 (D+)
/GPS/USB_D-: D703.2 (A2), U701.5 (USB_DM), USB701.A7 (D-), USB701.B7 (D-)
/GPS_RTX: R705.1; also elsewhere on the board
/GPS_TRX: R704.1; also elsewhere on the board
GND: C701.2, C702.1, C703.1, D701.1 (A1), D702.1 (A1), D703.1 (A1), J701.2 (Ext), R702.2, R703.2, U701.10 (GND), U701.12 (GND), U701.13 (GND), U701.24 (GND), USB701.A1 (GND), USB701.A12 (GND), USB701.B1 (GND), USB701.B12 (GND), USB701.S1 (SHIELD); also elsewhere on the board
GPSANT1: J701.1 (In), L701.1, U701.11 (RF_IN)
GPS_Backup: C703.2, U701.22 (V_BCKP); also elsewhere on the board
unnamed: C701.1, L701.2, R701.2
unnamed: D701.2 (A2), USB701.A4 (VBUS), USB701.A9 (VBUS), USB701.B4 (VBUS), USB701.B9 (VBUS)
unnamed: R704.2, U701.21 (RXD_/_SPI_MOSI)
unnamed: R705.2, U701.20 (TXD_/_SPI_MISO)
unnamed: R702.1, USB701.A5 (CC1)
unnamed: R703.1, USB701.B5 (CC2)
VCCRF: R701.1, U701.9 (VCC_RF)
VDD: C702.2, U701.7 (V_USB), U701.23 (VCC); also elsewhere on the board

Notes on the sheet:
CC pin 56kΩ for 0.5A 22kΩ for 1.5A 10kΩ for 3.0A
USB Type-C Connector

Parts:
C401, C404: 10μF; C_0603_1608Metric; LCSC C96446
C402, C403: 100nF; C_0402_1005Metric; LCSC C1525
U401: BME280; LCSC C92489

Connections:
/SCL: U401.4 (SCK); also elsewhere on the board
/SDA: U401.3 (SDI); also elsewhere on the board
GND: C401.2, C402.2, C403.2, C404.2, U401.1 (GND), U401.5 (SDO), U401.7 (GND); also elsewhere on the board
VDD: C401.1, C402.1, C403.1, C404.1, U401.2 (CSB), U401.6 (VDDIO), U401.8 (VDD); also elsewhere on the board

Parts:
BZ501: Buzzer; Buzzer_12x9.5RM7.6
C501: 10uF; C_0603_1608Metric; LCSC C96446
C502: 100nF; C_0402_1005Metric; LCSC C1525
D501: PMOS; LED_0805_2012Metric; LCSC C84256
D502: NORMAL; LED_0805_2012Metric; LCSC C2297
D503: ALERT; LED_0805_2012Metric; LCSC C84256
D504: D_Schottky; D_SMA; LCSC C22452
D505: D_Schottky; D_SOD-323; LCSC C191023
D506: NMOS; LED_0805_2012Metric; LCSC C84256
D507: LaunchDetection; LED_0805_2012Metric; LCSC C2296
F501: Polyfuse; Fuse_1812_4532Metric; LCSC C2843993
J501: LiPo 3 Cell; JST_VH_B2P-VH_1x02_P3.96mm_Vertical
J502: PowerSW; JST_VH_B2P-VH_1x02_P3.96mm_Vertical
J503: IGNITER; JST_VH_B2P-VH_1x02_P3.96mm_Vertical
J504: LaunchDetection; JST_PH_B3B-PH-K_1x03_P2.00mm_Vertical
Q501: Q_PMOS_GSD; SOT-23; LCSC C15127
Q502: Q_NPN_BEC; SOT-23; LCSC C20526
Q503: Q_NMOS_DGS; SOT-23-3; LCSC C20917
Q504: NMOS; SOT-23; LCSC C8545
R501, R506, R512, R514: 10k; R_0402_1005Metric; LCSC C25744
R502: 3.3k; R_0402_1005Metric; LCSC C25890
R503, R510: 1k; R_0402_1005Metric; LCSC C11702
R504, R505, R508, R509: 1k; R_0402_1005Metric; LCSC C25123
R507: 20mΩ; R_2010_5025Metric; LCSC C474229
R511, R513: 510; R_0402_1005Metric; LCSC C25123
U501: INA226; VSSOP-10_3x3mm_P0.5mm; LCSC C49851

Connections:
/ESP32core/GPIO14: R505.1; also elsewhere on the board
/Ldet: J504.2, R513.2; also elsewhere on the board
/SCL: U501.1 (A1), U501.5 (SCL); also elsewhere on the board
/SDA: U501.4 (SDA); also elsewhere on the board
/Separate/IGNITE+: R503.1; also elsewhere on the board
/Separate/IGNITE-: R511.1; also elsewhere on the board
GND: BZ501.2 (-), C501.2, C502.2, D501.1 (K), D502.1 (K), J501.2, J504.3, Q502.2 (E), Q503.2 (S), Q504.2 (S), R506.1, R512.1, R514.2, U501.7 (GND); also elsewhere on the board
unnamed: BZ501.1 (+), Q501.3 (D), R504.1, R506.2, R507.2, R508.1, U501.8 (Vbus), U501.10 (Vin+)
unnamed: D501.2 (A), R504.2
unnamed: D502.2 (A), R505.2
unnamed: D503.2 (A), R508.2
unnamed: D503.1 (K), D504.2 (A), J503.2 (Pin_1)
unnamed: D504.1 (K), D505.1 (K), Q503.3 (D)
unnamed: D505.2 (A), R509.2
unnamed: D506.1 (K), R509.1
unnamed: D507.2 (A), R510.2
unnamed: D507.1 (K), Q504.3 (D)
unnamed: J501.1, J502.1
unnamed: F501.1, J502.2
unnamed: J503.1 (Pin_2), R507.1, U501.9 (Vin-)
unnamed: Q501.1 (G), R501.2, R502.1
unnamed: F501.2, Q501.2 (S), R501.1
unnamed: Q502.1 (B), R503.2
unnamed: Q502.3 (C), R502.2
unnamed: Q503.1 (G), R511.2, R512.2
unnamed: Q504.1 (G), R513.1, R514.1
VDD: C501.1, C502.1, D506.2 (A), J504.1, R510.1, U501.2 (A0), U501.6 (VS); also elsewhere on the board

Notes on the sheet:
I_{hold}:5.0A I_{trip}:10.0A Max:16V
11.1V
定電流のDCDCを挟んでから入力予定 XL4015を想定
Max:4A
Diode変更済み Max:5A
I2C ADDR: 0x4D
Max:5.7A
待機中点灯 発射したら消灯
LaunchDetection

Parts:
C901: 100n; C_0402_1005Metric; LCSC C1525
D901: Flightpin; LED_0805_2012Metric; LCSC C84256
J901: Flightpin; JST_PH_S2B-PH-K_1x02_P2.00mm_Horizontal
R901, R903: 1k; R_0402_1005Metric; LCSC C11702
R902: 10k; R_0402_1005Metric; LCSC C25744

Connections:
/ESP32core/GPIO2/ADC1_CH1: C901.1, R901.1; also elsewhere on the board
GND: C901.2, R902.2, R903.2; also elsewhere on the board
unnamed: D901.2 (A), J901.2, R901.2, R902.1
unnamed: D901.1 (K), R903.1
VDD: J901.1; also elsewhere on the board
